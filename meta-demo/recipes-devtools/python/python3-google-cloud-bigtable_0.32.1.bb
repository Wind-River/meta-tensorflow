inherit setuptools3
require python-google-cloud-bigtable.inc
