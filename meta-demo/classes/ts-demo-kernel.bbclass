KERNEL_FEATURES_append=" features/media/media-usb-webcams.scc"
